# Keil uVision project Bootloader.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: M463YGCAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.3
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) IROM2(0x0F100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CFG_TUSB_MCU=OPT_MCU_M463
  c include: ..\CMSIS;..\Library\inc;..\User;..\ThirdParty\TinyUSB\hw\bsp;..\ThirdParty\TinyUSB\src;..\ThirdParty\TinyUSB\src\osal;..\ThirdParty\TinyUSB\src\device;..\ThirdParty\TinyUSB\src\common;..\ThirdParty\TinyUSB\src\class\cdc;..\ThirdParty\TinyUSB\hw\bsp\m463\boards\nutiny_sdk_m463
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0xf100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\Bootloader.sct
  group User
    ../User/: main.c msc_disk.c usb_descriptors.c
  group CMSIS
    ../CMSIS/: system_m460.c startup_m460.S
  group Library
    ../Library/src/: acmp.c bmc.c bpwm.c canfd.c ccap.c clk.c crc.c crypto.c dac.c eadc.c ebi.c ecap.c epwm.c eqei.c fmc.c gpio.c hbi.c hsusbd.c i2c.c i2s.c keystore.c kpi.c pdma.c qspi.c retarget.c rng.c rtc.c sc.c scuart.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c trng.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group ThirdParty/TinyUSB/src
    ../ThirdParty/TinyUSB/src/: tusb.c
    ../ThirdParty/TinyUSB/src/common/: tusb_fifo.c
    ../ThirdParty/TinyUSB/src/device/: usbd.c
    ../ThirdParty/TinyUSB/src/portable/nuvoton/m463/: dcd_m463.c
    ../ThirdParty/TinyUSB/src/class/msc/: msc_device.c
  group ThirdParty/TinyUSB/hw/bsp
    ../ThirdParty/TinyUSB/hw/bsp/: board.c
    ../ThirdParty/TinyUSB/hw/bsp/m463/: family.c
