# Keil uVision project App.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: M463YGCAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.3
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) IROM2(0x0F100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: App +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CMSIS;..\Library\inc;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0xf100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c
  group CMSIS
    ../CMSIS/: startup_m460.S system_m460.c
  group Library
    ../Library/src/: acmp.c bmc.c bpwm.c canfd.c ccap.c clk.c crc.c crypto.c dac.c eadc.c ebi.c ecap.c epwm.c eqei.c fmc.c gpio.c hbi.c hsusbd.c i2c.c i2s.c keystore.c kpi.c pdma.c qspi.c retarget.c rng.c rtc.c sc.c scuart.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c trng.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
